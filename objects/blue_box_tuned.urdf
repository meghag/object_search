Commit message: started on non greedy planner

File: objects/blue_box_tuned.urdf (robot description, URDF)
Before this commit: robot small_box_model, 1 links, 0 joints
Links:
- removed link small_box
- added link blue_box, mass 10; collision box size=0.08 0.08 0.15; visual box size=0.07 0.08 0.15
